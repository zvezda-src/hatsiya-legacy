KBRANCH ?= "dev-5.15-intel"
LINUX_VERSION ?= "5.15.24"

SRCREV="6eca78d14f7aef61a149d9f4d3a3ec818b98f18e"

require linux-aspeed.inc
