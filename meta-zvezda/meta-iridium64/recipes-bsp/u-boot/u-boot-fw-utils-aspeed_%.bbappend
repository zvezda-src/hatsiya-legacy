FILESEXTRAPATHS:prepend:iridium64 := "${THISDIR}/${PN}:"
SRC_URI:append:iridium64 = " file://0001-Change-settings-for-use-64MiB-image.patch"

