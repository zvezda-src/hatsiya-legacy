OBMC_IMAGE_EXTRA_INSTALL:append:iridium64 = " networkd-config"
