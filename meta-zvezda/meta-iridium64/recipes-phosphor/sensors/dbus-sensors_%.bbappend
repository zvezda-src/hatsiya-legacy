PACKAGECONFIG = " \
    psusensor \
    adcsensor \
    cpusensor \
    fansensor \
    intrusionsensor \
    hwmontempsensor \
    "
