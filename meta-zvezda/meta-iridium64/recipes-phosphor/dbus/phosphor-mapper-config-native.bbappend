PHOSPHOR_MAPPER_CONFIGS:append:zvezda = " intel-dbus-interfaces-mapper-config-native"
