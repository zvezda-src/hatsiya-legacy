PACKAGECONFIG:append:iridium64 = " nic-ethtool"
PACKAGECONFIG:remove:iridium64 = "uboot-env"